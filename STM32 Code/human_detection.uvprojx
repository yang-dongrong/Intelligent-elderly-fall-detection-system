# Keil uVision project human_detection.uvprojx, settings and files
target temp (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Pulse_Generator +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\FWLIB\inc;.\CMSIS;.\HARDWEAR;.\HARDWARE\DS18B20;.\HARDWARE\ATGPS;.\HARDWARE\usart;.\HARDWARE\NET\MQTT;.\HARDWARE\NET\onenet\inc;.\SYSTEM\delay;.\HARDWARE\NET\device\inc;.\HARDWARE\MPU6050;.\HARDWARE\OLED;.\HARDWARE\MAX30100;.\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group FWLIB
    ./FWLIB/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ./USER/: main.c stm32f10x_it.c sys.c
    ./SYSTEM/delay/: delay.c
  group STARTUP
    ./CMSIS/startup/arm/: startup_stm32f10x_md.s
  group HARDWEAR
    ./HARDWARE/usart/: timer3.c uart.c tim2.c
    ./HARDWARE/ATGPS/: ATGPS.c
  group DS18B20_LCD
    ./HARDWARE/DS18B20/: DS18B20.c
    ./HARDWARE/OLED/: oled.c
    ./HARDWARE/MAX30100/: MAX30100.c MAX30100_BeatDetector.c MAX30100_Filters.c MAX30100_PulseOximeter.c MAX30100_SpO2Calculator.c
    ./HARDWARE/IIC/: myiic.c
  group Onenet
    ./HARDWARE/NET/MQTT/: MqttKit.c
    ./HARDWARE/NET/onenet/src/: onenet.c
    ./HARDWARE/NET/device/src/: m6312.c
  group MPU6050
    ./HARDWARE/MPU6050/: inv_mpu.c inv_mpu_dmp_motion_driver.c mpu6050.c mpuiic.c
